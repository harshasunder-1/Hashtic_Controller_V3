# IAR project JHASHTICSourceCodeV1.ewp, settings and files
configuration JHASHTICSourceCodeV1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32G474QE ST STM32G474QE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4; USE_HAL_DRIVER; STM32G474xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy; ../MCSDK_v5.4.7/MotorControl/MCSDK/MCLib/Any/Inc; ../MCSDK_v5.4.7/MotorControl/MCSDK/MCLib/G4xx/Inc; ../MCSDK_v5.4.7/MotorControl/MCSDK/UILibrary/Inc; ../MCSDK_v5.4.7/MotorControl/MCSDK/SystemDriveParams; ../Drivers/CMSIS/Device/ST/STM32G4xx/Include; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/DSP/Include; ..\Drivers\AS5x47P; ..\Drivers\TMCM\Inc; ..\..\..\Hashtic_Controller_V2\JHASHTICSourceCodeV1\Drivers\EEPROM\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: JHASHTICSourceCodeV1.hex
  ILINK.IlinkOutputFile: JHASHTICSourceCodeV1.out
  ILINK.IlinkIcfFile: stm32g474xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g474xx.s
  group Application/User
    ../Src/: dac_ui.c main.c mc_api.c mc_config.c mc_interface.c mc_math.c mc_parameters.c mc_tasks.c motor_control_protocol.c motorcontrol.c regular_conversion_manager.c stm32g4xx_hal_msp.c stm32g4xx_it.c stm32g4xx_mc_it.c ui_task.c user_interface.c
  group Drivers/AS5x47P
    ../Drivers/AS5x47P/: AS5x47P.c EncoderFns.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Drivers/EmulatedEeprom
    ../Drivers/EEPROM/Src/: eeprom_emul.c flash_interface.c motor_config.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_cordic.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_ll_adc.c stm32g4xx_ll_pwr.c
  group Drivers/TMCM
    ../Drivers/TMCM/Src/: Configuration.c ControlFns.c EncFaults.c FDCAN.c PRECHARGE.c StartSequence.c StateMachine.c StopController.c TemperatureLogic.c
  group Middlewares/MotorControl
    ../MCSDK_v5.4.7/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c enc_align_ctrl.c encoder_speed_pos_fdbk.c motor_power_measurement.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c pwm_common.c pwm_curr_fdbk.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c speed_pos_fdbk.c speed_torq_ctrl.c state_machine.c virtual_speed_sensor.c
    ../MCSDK_v5.4.7/MotorControl/MCSDK/UILibrary/Src/: dac_common_ui.c frame_communication_protocol.c ui_irq_handler.c usart_frame_communication_protocol.c
    ../MCSDK_v5.4.7/MotorControl/MCSDK/MCLib/G4xx/Src/: ics_g4xx_pwm_curr_fdbk.c
    ../MCSDK_v5.4.7/MotorControl/lib/: libmc-iar_M4.a
